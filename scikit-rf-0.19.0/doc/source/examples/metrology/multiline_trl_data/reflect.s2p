!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (one-way two-port):
!   401 points, 1 GHz to 100 GHz, reference 50 ohm
!   highest |S21| = -55.37 dB at 80.2 GHz (marker M1); lowest = -131.2 dB at 23.27 GHz (marker M2)
!   lowest |S11| = -13.9 dB at 97.28 GHz (marker M3), VSWR 1.50, Z = 33.4 - j2.4 ohm
!   |S11| at or under -10 dB: 72.27614 GHz to 72.61464 GHz (338.5 MHz wide, 0.467 % of centre); 72.95634 GHz to 73.31738 GHz (361 MHz wide, 0.494 % of centre); 96.3 GHz to 97.52 GHz (1.219 GHz wide, 1.26 % of centre) (the widest 3 of 61)
!   |S22| runs from -17.8 to -1.2 dB; largest |S21 - S12| = 0.0022
!   the Smith chart shows 95.79 GHz to 99.01 GHz only
!   S11 on the Smith chart (normalised r, x): 95.79 GHz: 0.69, +0.18; 97.28 GHz: 0.67, -0.05; 97.77 GHz: 1.12, +0.63; 99.01 GHz: 1.94, -0.27
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 1 GHz  -1.1  -76.9  -69.4  -1.4
! 2.732 GHz  -1.9  -66.2  -100.0  -1.7
! 17.58 GHz  -4.5  -68.1  -91.9  -4.2
! 23.27 GHz  -5.3  -131.2  -65.3  -5.5
! 24.51 GHz  -4.9  -64.9  -87.5  -5.2
! 34.16 GHz  -7.8  -96.5  -66.3  -7.4
! 41.59 GHz  -6.3  -57.3  -79.8  -7.5
! 42.83 GHz  -7.2  -78.5  -74.1  -8.6
! 45.3 GHz  -7.8  -67.4  -76.6  -11.1
! 50.5 GHz  -9.5  -61.3  -76.6  -11.0
! 57.18 GHz  -7.4  -71.9  -85.2  -11.0
! 62.13 GHz  -7.7  -56.1  -69.4  -7.7
! 67.08 GHz  -8.0  -84.0  -73.9  -10.6
! 75.5 GHz  -9.1  -65.0  -85.0  -8.5
! 77.48 GHz  -11.6  -80.5  -61.4  -14.4
! 80.2 GHz  -12.4  -55.4  -68.1  -15.1
! 83.67 GHz  -11.4  -64.8  -83.1  -8.8
! 95.79 GHz  -13.5  -61.6  -65.5  -9.4
! 97.28 GHz  -13.9  -59.9  -68.6  -9.9
! 97.77 GHz  -10.7  -72.6  -82.3  -17.8
! 99.01 GHz  -9.6  -76.3  -63.3  -16.0
! 100 GHz  -12.8  -72.2  -99.6  -10.2
