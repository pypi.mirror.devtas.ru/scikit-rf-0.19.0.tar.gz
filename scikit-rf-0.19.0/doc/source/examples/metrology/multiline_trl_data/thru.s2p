!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (through path):
!   401 points, 1 GHz to 100 GHz, reference 50 ohm
!   highest |S21| = -1.51 dB at 1.495 GHz (marker M1); lowest = -12.7 dB at 99.01 GHz (marker M2)
!   lowest |S11| = -51.6 dB at 13.38 GHz (marker M3), VSWR 1.01, Z = 50.1 - j0.254 ohm
!   |S11| at or under -10 dB: 1.147 GHz to 2.479 GHz (1.332 GHz wide, 73.5 % of centre); 2.488 GHz to 6.18 GHz (3.692 GHz wide, 85.2 % of centre); 7.489 GHz to end of sweep (the widest 3 of 4)
!   |S22| runs from -43.3 to -8.8 dB; largest |S21 - S12| = 0.11
!   the Smith chart shows 10.9 GHz to 16.1 GHz only
!   S11 on the Smith chart (normalised r, x): 10.9 GHz: 1.15, -0.28; 13.13 GHz: 1.62, +0.15; 14.37 GHz: 0.94, -0.43; 16.1 GHz: 1.19, +0.33
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 1 GHz  -7.1  -2.2  -1.3  -11.3
! 1.495 GHz  -15.8  -1.5  -1.5  -14.6
! 10.9 GHz  -16.7  -4.1  -4.1  -20.0
! 12.63 GHz  -12.1  -4.9  -4.5  -14.3
! 13.13 GHz  -12.3  -4.9  -5.1  -11.5
! 13.38 GHz  -51.6  -4.6  -4.5  -39.2
! 14.37 GHz  -13.1  -5.4  -4.8  -14.5
! 14.61 GHz  -13.0  -5.2  -5.2  -13.2
! 16.1 GHz  -15.3  -5.2  -5.2  -16.2
! 17.58 GHz  -17.1  -5.2  -5.1  -21.5
! 34.16 GHz  -24.1  -7.5  -7.2  -17.1
! 43.82 GHz  -15.0  -8.7  -8.6  -13.4
! 44.56 GHz  -23.1  -8.3  -8.3  -43.3
! 50.5 GHz  -26.4  -9.2  -8.9  -16.4
! 67.08 GHz  -16.7  -10.2  -10.0  -19.1
! 68.81 GHz  -25.5  -10.2  -10.2  -21.9
! 70.05 GHz  -20.6  -10.4  -10.5  -27.0
! 71.04 GHz  -24.9  -10.7  -10.4  -17.9
! 75.5 GHz  -19.4  -10.7  -10.5  -24.4
! 83.67 GHz  -22.2  -11.3  -11.2  -26.3
! 99.01 GHz  -16.9  -12.7  -12.5  -15.9
! 100 GHz  -22.7  -12.5  -12.4  -19.3
